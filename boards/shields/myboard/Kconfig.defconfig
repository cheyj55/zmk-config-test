## boards/shields/myboard/Kconfig.defconfig
```kconfig
if SHIELD_MYBOARD

config ZMK_KEYBOARD_NAME
    default "myboard"

endif # SHIELD_MYBOARD
```
